# Keil uVision project main.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\stdlib\inc;.\user\inc;..\stm;.\user\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ./CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ./CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ./stdlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_tim.c stm32f10x_usart.c
  group USER
    ./user/inc/: stm32f10x_conf.h stm32f10x_it.h
    ./user/src/: stm32f10x_it.c Delay.c lcd12864.c key1.c LED.c Lock.c IIC.c AT2402.c timer.c sys.c usart3.c as608.c key.c
    ./user/: main.c
